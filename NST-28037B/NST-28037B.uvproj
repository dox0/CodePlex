# Keil uVision project NST-28037B.uvproj, settings and files
target NST-28037B (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NST-28037B +hex
  c flags: Optim=1 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_LD_VL
  c include: .\;..\STM32Fxxx_X893;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000800 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./: startup_stm32f10x_ld_vl.s main.c system_stm32f10x.c stm32f10x_conf.h NST-28037B.c font.c bootloader.c
  group STM32_Lib
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32_X893
    ../STM32Fxxx_X893/: gpio.c
